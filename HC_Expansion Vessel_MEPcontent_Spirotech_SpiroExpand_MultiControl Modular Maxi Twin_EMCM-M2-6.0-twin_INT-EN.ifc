Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2025-07-24T15:53:33+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M2-M9_INT-EN:EMCM-M2-6.0-twin, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M2-M9_INT-EN:EMCM-M2-6.0-twin:199825
In: Level 1
Type - Material: Color RGB 040-040-040 (2), Color RGB 182-182-182, Color RGB 200-200-200 (2), Color RGB 181-166-066, Color RGB 255-000-000, Color RAL 1003, Color RGB 255-255-255, Color RGB 055-055-055, Color RGB 115-115-115, Color RGB 200-000-000
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 1075 mm; Height: 1368 mm; Overflow Diameter: 38.1 mm; Pressure Diameter: 38.1 mm; Refill Diameter: 12.7 mm; Suction Diameter: 38.1 mm; Use Nominal Diameter: yes; Width: 1142 mm
Type - Electrical - Loads - Power: 2400 W
Type - Electrical Engineering - Phase: 1; Voltage: 400 V
Type - Identity Data - Article Description: SpiroExpand MultiControl Modular Maxi Twin; Article Type: EMCM-M2-6.0-twin; Base Family Version: 25.08; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: SpiroExpand MultiControl Modular Maxi Twin; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 25.08; GLN: 8717811000007; GTIN: 8717811042878; Manufacturer: Spirotech; Manufacturer Art. No.: EMCM-M2-6.0-twin; Manufacturer URL: https://www.eder-spirotech.at/produkte/expansionsautomaten/multicontrol-modular-maxi-twin-272?variant=2016; MEPcontent Class: VACUUM_DEGASSER; Model: EMCM-M2-6.0-twin; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: SpiroExpand; Revit Version: 2023; Type Name: EMCM-M2-6.0-twin; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Dark Grey: Color RGB 115-115-115; Grey: Color RGB 200-200-200; Light Black: Color RGB 055-055-055; Red: Color RGB 200-000-000; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Other - Category: Mechanical Equipment; 141: yes; 178: no; 220: no; Bottom Plate: 657.5 mm; C: 365.35 mm; D: 1292 mm; E: 560 mm; F: 915 mm; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M2-M9_INT-EN; Flange: no; G: 188 mm; Height to Rectangle: 12 mm; I: 118 mm; J: 110 mm; Legs Height: 138 mm; Middle Plate: 438.5 mm; Overflow Pipe Length: 809 mm; Overflow Pipe Nominal: 38.1 mm; Overflow Pipe Radius: 24.15 mm; Pipe Angle: 11 deg; Pipe Depth: 93 mm; Pipe Length: 781.6 mm; Pressure Pipe Nominal: 38.1 mm; Pressure Pipe Radius: 24.15 mm; Pump 1: yes; Pump 2: no; Pump Body 1: 100.1 mm; Pump Body 2: 18 mm; Pump Body Height: 272.9 mm; Pumps Distance: 908 mm; Rear Pump: no; Rectangle Depth: 109 mm; Rectangle Height: 216 mm; Rectangle Width: 268 mm; S10: no; S4-S10: no; S4-S9: yes; Second Top Part: 41 mm; Second Type: no; Service Space Height: 1359 mm; Simple Geometry: yes; Suction Pipe Nominal: 38.1 mm; Suction Pipe Radius: 24.15 mm; Top Part of Pump Height: 219 mm; Unit Depth: 903.5 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Material: Color RGB 040-040-040, Color RGB 182-182-182, Color RGB 200-200-200, Color RGB 181-166-066, Color RGB 255-000-000, Color RAL 1003, Color RGB 255-255-255, Color RGB 055-055-055, Color RGB 115-115-115, Color RGB 200-000-000
Pset_BuildingElementProxyCommon - Reference: EMCM-M2-6.0-twin
Pset_EnvironmentalImpactIndicators - Reference: EMCM-M2-6.0-twin
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 26.2033 m2; Volume: 0.515616 m3
Identity Data - Mark: 1
Mechanical - Flow In: 0 m3/s; Pressure Flow: 0 m3/s; Refill Flow: 0 m3/s; Suction Flow: 0 m3/s; System Classification: Undefined,Power
Other - Angle: 180 deg; Back Clearance Safe: 0 mm; Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M2-M9_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi Twin_M2-M9_INT-EN: EMCM-M2-6.0-twin; Front Clearance Safe: 500 mm; Front Pump: yes; Left Clearance Safe: 500 mm; Left Side Pipe: 290 mm; Reference Line Length: 62 mm; Refill Angle: 345.39 mm; Right Clearance Safe: 500 mm; Right Side Pipe: 320 mm; Supply Length: 300 mm; Top Clearance Safe: 500 mm; Type: EMCM-M2-6.0-twin; Type Id: 199791
Phasing - Phase Created: New Construction
Visibility - Front Clearance: 500 mm; Left Clearance: 500 mm; Left Side Connection: yes; Right Clearance: 500 mm; Right Side Connection: no; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection | PredefinedType
2 x Port_199825 | SOURCE | PIPE
2 x Port_199825 | SINK | PIPE
Port_199825 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
